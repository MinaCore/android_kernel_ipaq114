## drivers/android/Kconfig
```kconfig
config ANDROID_POWER
    bool "Android power driver"
    depends on WAKELOCK
    default y
```
